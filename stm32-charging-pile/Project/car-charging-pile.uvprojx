# Keil uVision project car-charging-pile.uvprojx, settings and files
target STM32F103ZE ()
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(72000000) ESEL ELITTLE
